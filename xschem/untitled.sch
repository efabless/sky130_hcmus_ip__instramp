v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_high_po_0p69.sym} 60 -50 0 0 {name=R1
L=1.4041
model=res_high_po_0p69
spiceprefix=X
mult=1}
