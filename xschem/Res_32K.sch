** sch_path: xschem/Res_32K.sch
**.subckt Res_32K R RR VSS
*.iopin R
*.iopin RR
*.ipin VSS
x1 VSS net1 RR Res_16K
x2 VSS R net1 Res_16K
**.ends
.end
