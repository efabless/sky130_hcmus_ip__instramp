** sch_path: xschem/Res_16K.sch
**.subckt Res_16K R RR VSS
*.iopin R
*.iopin RR
*.ipin VSS
x1 VSS net1 RR Res_8K
x2 VSS R net1 Res_8K
**.ends
.end
