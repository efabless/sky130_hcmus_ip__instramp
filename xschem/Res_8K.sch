** sch_path: xschem/Res_8K.sch
**.subckt Res_8K R RR VSS
*.iopin R
*.iopin RR
*.ipin VSS
x1 VSS net1 RR Res_4K
x2 VSS R net1 Res_4K
**.ends
.end
