** sch_path: xschem/untitled-2.sch
**.subckt untitled-2 R RR VSS
*.iopin R
*.iopin RR
*.ipin VSS
x1 VSS net1 RR Res_4K
x2 VSS R net1 Res_4K
**.ends
.end
